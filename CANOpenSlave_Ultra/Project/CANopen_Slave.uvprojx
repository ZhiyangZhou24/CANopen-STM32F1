# Keil uVision project CANopen_Slave.uvprojx, settings and files
target CANopen_Slave (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CANopen_Slave
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD
  c include: ..\App\canopen;..\Bsp;..\CANOpen\inc;..\FreeRTOS\include;..\Libraries\CMSIS\CoreSupport;..\Libraries\CMSIS\DeviceSupport;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\FreeRTOS\portable\RVDS\ARM_CM3;..\CANOpen\inc\stm32;..\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../Libraries/CMSIS/DeviceSupport/: system_stm32f10x.c
    ../Libraries/CMSIS/DeviceSupport/startup/: startup_stm32f10x_hd.s
  group STM32F10x_StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_can.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group FreeRTOS
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../App/: FreeRTOSConfig.h
  group CANopen/src
    ../CANOpen/src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
  group CANopen/inc/stm32
    ../CANOpen/inc/stm32/: applicfg.h canfestival.h timerscfg.h
  group Bsp
    ../Bsp/: bsp.c bsp_can.c bsp_timer.c bsp_usart.c
  group Application
    ../App/: app.c main.c stm32f10x_it.c
  group Application/canopen
    ../App/canopen/: canopen_app.c canopen_drv.c Slave.c
