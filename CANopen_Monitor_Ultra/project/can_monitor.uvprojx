# Keil uVision project can_monitor.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: can_monitor
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\application\inc;..\drivers;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries;..\drivers\touch;..\drivers\LCD;..\drivers\delay;..\drivers\SRAM;..\drivers\at24c02;..\drivers\SDIO;..\STemWinLibrary532\inc;..\STemWinLibrary532\Config;..\drivers\MALLOC;..\application\canopen;..\Bsp;..\CANOpen\inc;..\CANOpen\inc\stm32
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT6: RAM 0x64000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group application
    ../application/src/: main.c
    ../application/inc/: main.h
  group App/canopen
    ../application/canopen/: canopen_app.c canopen_drv.c Master.c
  group Bsp
    ../Bsp/: bsp.c bsp_can.c bsp_timer.c bsp_usart.c
    ../drivers/delay/: delay.c
  group CANopen/src
    ../CANOpen/src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
  group CANopen/inc/stm32
    ../CANOpen/inc/stm32/: applicfg.h canfestival.h timerscfg.h
  group GUIFile
    ../STemWinLibrary532/Software/: SoftwareWindowDLG.c
  group emWin
    ../STemWinLibrary532/Config/: GUI_X_Touch_Anlaog.c GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c
    ../STemWinLibrary532/OS/: GUI_X.c
    ../STemWinLibrary532/Lib/: STemWin532_CM3_Keil.lib
  group sys
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    ../Libraries/: stm32f10x_it.c
  group drivers/Touch
    ../drivers/LCD/: Touch.c
  group drivers/LCD
    ../drivers/LCD/: LCDhard.c
  group Libraries
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_can.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_dma.c
  group sram
    ../drivers/SRAM/: sram.c
  group at24c02
    ../drivers/at24c02/: at24c02.c i2c.c
  group SDIO
    ../drivers/SDIO/: sdio_sdcard.c
